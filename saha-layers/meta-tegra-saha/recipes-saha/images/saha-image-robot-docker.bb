require saha-image-robot.inc

CORE_IMAGE_BASE_INSTALL += "packagegroup-saha-docker-images"
