require saha-image-robot.inc
