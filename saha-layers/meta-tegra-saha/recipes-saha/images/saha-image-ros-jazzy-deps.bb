DESCRIPTION = "Saha ROS 2 Jazzy dependency image for tegra"

require saha-image-base.bb

CORE_IMAGE_BASE_INSTALL += "packagegroup-saha-ros-jazzy-deps"
