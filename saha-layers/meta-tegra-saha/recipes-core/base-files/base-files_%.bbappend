FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"

hostname = "soybean"
